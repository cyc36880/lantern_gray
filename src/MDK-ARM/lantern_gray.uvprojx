# Keil uVision project lantern_gray.uvprojx, settings and files
target lantern_gray (::::)
  device: CW32L010F8 WHXY
  pack: WHXY.CW32L010_DFP.1.0.2
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lantern_gray
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Core\Inc;..\myCode\User\Inc;..\Drivers\CW32L010_HAL_Driver\Inc;..\myCode\myCode\Inc;..\myCode\Drive\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application/MDK-ARM
    ./: startup_cw32l010.s
    ../Core/Src/: system_cw32l010.c
  group Application/User/Core
    ../Core/Src/: cw32l010_sysctrl.c cw32l010_gpio.c cw32l010_flash.c cw32l010_systick.c cw32l010_uart.c cw32l010_i2c.c
  group Drive
    ../myCode/Drive/src/: ws2812.c
  group User
    ../myCode/User/Src/: main.c gpio.c i2c.c interrupts_cw32l010.c uart.c
  group myCode
    ../myCode/myCode/: myMain.c
    ../myCode/myCode/Src/: register.c
software components: CMSIS:CORE 5.6.0
